# IAR project cyt4bb7_cm_7_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CYT4BB_M7 Infineon CYT4BB_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviibh4m; CYT4BB7CEE; CY_USE_PSVP=0; CY_MCU_rev_b; CPU_BOARD_REVB; CY_CORE_CM7_1; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCDiagSuppress: Pa082,Pa134
  ICCARM.CCIncludePath2: ..\..\..\E8_camera\libraries\sdk\common\hdr; ..\..\..\E8_camera\libraries\sdk\common\hdr\cmsis\include; ..\..\..\E8_camera\libraries\sdk\common\src\drivers; ..\..\..\E8_camera\libraries\sdk\common\src\mw; ..\..\..\E8_camera\libraries\sdk\tviibh4m\hdr; ..\..\..\E8_camera\libraries\sdk\tviibh4m\hdr\ip; ..\..\..\E8_camera\libraries\sdk\tviibh4m\hdr\mcureg; ..\..\..\E8_camera\libraries\sdk\tviibh4m\src; ..\..\..\E8_camera\libraries\sdk\tviibh4m\src\interrupts; ..\..\..\E8_camera\libraries\sdk\tviibh4m\src\mw; ..\..\..\E8_camera\libraries\sdk\tviibh4m\src\drivers; ..\..\..\E8_camera\libraries\sdk\tviibh4m\src\system; ..\..\..\E8_camera\libraries\sdk\common\hdr\cmsis\dsp; ..\..\..\E8_camera\libraries\zf_common; ..\..\..\E8_camera\libraries\zf_driver; ..\..\..\E8_camera\libraries\zf_device; ..\..\..\E8_camera\libraries\zf_components; ..\..\user; ..\..\code
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cyt4bb7_cm_7_1.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_cm7_1_=0; _LINK_flash_=0
  ILINK.IlinkIcfFile: ..\icf\linker_directives_tviibh.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\E8_camera\libraries\sdk\tviibh4m\src\drivers\crypto\libs\libcrypto_server_cm0plus_iar.a; ..\..\..\E8_camera\libraries\zf_device\zf_device_config.a; ..\..\..\E8_camera\libraries\sdk\common\hdr\cmsis\dsp\iar_cortexM7lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group code
    ../../code/: 本文件夹作用.txt
  group doc
    ../../../E8_camera/libraries/doc/: GPL3_permission_statement.txt version.txt
  group sdk/hdr
    ../../../E8_camera/libraries/sdk/common/hdr/: cy_project.h
  group sdk/hdr/cmsis/dsp
    ../../../E8_camera/libraries/sdk/common/hdr/cmsis/dsp/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h
  group sdk/hdr/cmsis/include
    ../../../E8_camera/libraries/sdk/common/hdr/cmsis/include/: cachel1_armv7.h cmsis_compiler.h core_cm0plus.h
  group sdk/hdr/rev_b
    ../../../E8_camera/libraries/sdk/tviibh4m/hdr/: bb_bsp_tviibh4m.h bb_bsp_tviibh4m_revb.h cy_device_headers.h cyt4bb_config.h
  group sdk/hdr/rev_b/ip
    ../../../E8_camera/libraries/sdk/tviibh4m/hdr/ip/: cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v3.h cyip_headers.h cyip_hsiom_v3.h cyip_i2s_v2.h cyip_ipc.h cyip_lin.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_v2.h cyip_smartio_v3.h cyip_smif_v2.h cyip_srss_v3.h cyip_tcpwm_v2.h
  group sdk/src/drivers/adc
    ../../../E8_camera/libraries/sdk/common/src/drivers/adc/: cy_adc.c cy_adc.h
  group sdk/src/drivers/audioss
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/audioss/: cy_i2s.c cy_i2s.h
  group sdk/src/drivers/canfd
    ../../../E8_camera/libraries/sdk/common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group sdk/src/drivers/cpu
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group sdk/src/drivers/crypto
    ../../../E8_camera/libraries/sdk/common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group sdk/src/drivers/dma
    ../../../E8_camera/libraries/sdk/common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group sdk/src/drivers/ethernet
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/ethernet/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h cy_ethif.c cy_ethif.h edd.c edd_int.h edd_rx.c edd_tx.c emac_regs.h emac_regs_macro.h log.h
  group sdk/src/drivers/evtgen
    ../../../E8_camera/libraries/sdk/common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group sdk/src/drivers/flash
    ../../../E8_camera/libraries/sdk/common/src/drivers/flash/: cy_flash.c
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/flash/: cy_flash.h
  group sdk/src/drivers/gpio
    ../../../E8_camera/libraries/sdk/common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group sdk/src/drivers/ipc
    ../../../E8_camera/libraries/sdk/common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group sdk/src/drivers/lin
    ../../../E8_camera/libraries/sdk/common/src/drivers/lin/: cy_lin.c cy_lin.h
  group sdk/src/drivers/lvd
    ../../../E8_camera/libraries/sdk/common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group sdk/src/drivers/mcwdt
    ../../../E8_camera/libraries/sdk/common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group sdk/src/drivers/mpu
    ../../../E8_camera/libraries/sdk/common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group sdk/src/drivers/prot
    ../../../E8_camera/libraries/sdk/common/src/drivers/prot/: cy_prot.c cy_prot.h
  group sdk/src/drivers/scb
    ../../../E8_camera/libraries/sdk/common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group sdk/src/drivers/sd_host
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/sd_host/: cy_sd_host.c cy_sd_host.h
  group sdk/src/drivers/smartio
    ../../../E8_camera/libraries/sdk/common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group sdk/src/drivers/smif
    ../../../E8_camera/libraries/sdk/common/src/drivers/smif/common/: cy_smif.c cy_smif.h cy_smif_memslot.c cy_smif_memslot.h
    ../../../E8_camera/libraries/sdk/common/src/drivers/smif/ver2/: cy_smif_ver_specific.c cy_smif_ver_specific.h
  group sdk/src/drivers/srom
    ../../../E8_camera/libraries/sdk/common/src/drivers/srom/: cy_srom.c cy_srom.h
  group sdk/src/drivers/sysclk
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group sdk/src/drivers/sysflt
    ../../../E8_camera/libraries/sdk/common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/sysflt/: cy_sysflt_config.h
  group sdk/src/drivers/sysint
    ../../../E8_camera/libraries/sdk/common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group sdk/src/drivers/syslib
    ../../../E8_camera/libraries/sdk/common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    ../../../E8_camera/libraries/sdk/common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group sdk/src/drivers/syspm
    ../../../E8_camera/libraries/sdk/common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group sdk/src/drivers/sysreghc
    ../../../E8_camera/libraries/sdk/tviibh4m/src/drivers/sysreghc/: cy_sysreghc.c cy_sysreghc.h
  group sdk/src/drivers/sysreset
    ../../../E8_camera/libraries/sdk/common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group sdk/src/drivers/sysrtc
    ../../../E8_camera/libraries/sdk/common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group sdk/src/drivers/systick
    ../../../E8_camera/libraries/sdk/common/src/drivers/systick/: cy_systick.c cy_systick.h
  group sdk/src/drivers/syswdt
    ../../../E8_camera/libraries/sdk/common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group sdk/src/drivers/tcpwm
    ../../../E8_camera/libraries/sdk/common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group sdk/src/drivers/trigmux
    ../../../E8_camera/libraries/sdk/common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group sdk/src/interrupts/rev_b
    ../../../E8_camera/libraries/sdk/tviibh4m/src/interrupts/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group sdk/src/mw/button
    ../../../E8_camera/libraries/sdk/common/src/mw/button/: cy_button.c cy_button.h
  group sdk/src/mw/eth_phy
    ../../../E8_camera/libraries/sdk/tviibh4m/src/mw/eth_phy/: cy_dp83867.c cy_dp83867.h
  group sdk/src/mw/flash
    ../../../E8_camera/libraries/sdk/common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group sdk/src/mw/power
    ../../../E8_camera/libraries/sdk/tviibh4m/src/mw/power/: cy_power.c cy_power.h
  group sdk/src/mw/semihosting
    ../../../E8_camera/libraries/sdk/common/src/mw/semihosting/: cy_semihosting.c cy_semihosting.h
  group sdk/src/mw/smif_mem
    ../../../E8_camera/libraries/sdk/tviibh4m/src/mw/smif_mem/: cy_smif_device_common.c cy_smif_device_common.h cy_smif_hb_flash.c cy_smif_hb_flash.h cy_smif_s25fl.c cy_smif_s25fl.h cy_smif_s25fs.c cy_smif_s25fs.h cy_smif_semp.c cy_smif_semp.h
  group sdk/src/mw/sw_timer
    ../../../E8_camera/libraries/sdk/common/src/mw/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group sdk/src/startup
    ../../../E8_camera/libraries/sdk/common/src/startup/: startup.c startup_customize.h
    ../../../E8_camera/libraries/sdk/common/src/startup/iar/: startup_cm7.s
  group sdk/src/system/rev_b
    ../../../E8_camera/libraries/sdk/tviibh4m/src/system/: system_cyt4bb.h system_tviibh4m_cm7.c
  group user
    ../../user/: cm7_1_isr.c main_cm7_1.c
  group zf_common
    ../../../E8_camera/libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h
  group zf_components
    ../../../E8_camera/libraries/zf_components/: seekfree_assistant.c seekfree_assistant.h seekfree_assistant_interface.c
  group zf_device
    ../../../E8_camera/libraries/zf_device/: zf_device_ble6a20.c zf_device_ble6a20.h zf_device_config.h zf_device_dl1a.c zf_device_dl1a.h zf_device_dl1b.c zf_device_dl1b.h zf_device_gnss.c zf_device_gnss.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu660rb.c zf_device_imu660rb.h zf_device_imu660rc.c zf_device_imu660rc.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_ips200pro.c zf_device_ips200pro.h zf_device_key.c zf_device_key.h zf_device_menc15a.c zf_device_menc15a.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_oled.c zf_device_oled.h zf_device_pmw3901.c zf_device_pmw3901.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_uart_receiver.c zf_device_uart_receiver.h zf_device_wifi_spi.c zf_device_wifi_spi.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h 外设文件说明.txt
  group zf_driver
    ../../../E8_camera/libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_delay.c zf_driver_delay.h zf_driver_dma.c zf_driver_dma.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_ipc.c zf_driver_ipc.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h
